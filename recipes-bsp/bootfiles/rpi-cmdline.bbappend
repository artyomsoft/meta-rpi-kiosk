CMDLINE:append = " quiet loglevel=0 vt.global_cursor_default=0"
